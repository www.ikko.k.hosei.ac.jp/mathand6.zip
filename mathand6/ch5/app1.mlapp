classdef app1 < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        UIFigure       matlab.ui.Figure
        FreqKnobLabel  matlab.ui.control.Label
        FreqKnob       matlab.ui.control.Knob
        AmpKnobLabel   matlab.ui.control.Label
        AmpKnob        matlab.ui.control.Knob
        UIAxes         matlab.ui.control.UIAxes
    end

  properties (Access = private)
        Property % Description
        Amp=1;
        Freq=1;
        t=(0:1024)*0.001;
        data=sin(2*pi*(0:1024)*0.001);
  end

    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            plot(app.UIAxes,app.t,app.data);
            app.UIAxes.XLim=[0,app.t(end)];
            app.UIAxes.YLim=[-100,100];            
        end

        % Value changed function: AmpKnob
        function AmpKnobValueChanged(app, event)
            app.Amp = app.AmpKnob.Value;
            app.data=app.Amp*sin(2*pi*app.Freq*app.t);
            plot(app.UIAxes,app.t,app.data);
            app.UIAxes.XLim=[0,app.t(end)];
            app.UIAxes.YLim=[-100,100];   
        end

        % Value changed function: FreqKnob
        function FreqKnobValueChanged(app, event)
            app.Freq = app.FreqKnob.Value;
            app.data=app.Amp*sin(2*pi*app.Freq*app.t);
            plot(app.UIAxes,app.t,app.data);
            app.UIAxes.XLim=[0,app.t(end)];
            app.UIAxes.YLim=[-100,100];       
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.UIFigure = uifigure;
            app.UIFigure.Name = 'UI Figure';
            app.FreqKnobLabel = uilabel(app.UIFigure);
            app.FreqKnobLabel.Text = 'Freq';
            app.FreqKnob = uiknob(app.UIFigure, 'continuous');
            app.FreqKnob.ValueChangedFcn = createCallbackFcn(app, @FreqKnobValueChanged, true);
            app.AmpKnobLabel = uilabel(app.UIFigure);
            app.AmpKnobLabel.Text = 'Amp';
            app.AmpKnob = uiknob(app.UIFigure, 'continuous');
            app.AmpKnob.ValueChangedFcn = createCallbackFcn(app, @AmpKnobValueChanged, true);
            app.UIAxes = uiaxes(app.UIFigure);
            title(app.UIAxes, 'Title')
            xlabel(app.UIAxes, 'X')
            ylabel(app.UIAxes, 'Y')
        end
    end

    methods (Access = public)

        % Construct app
        function app = app1

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.UIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.UIFigure)
        end
    end
end