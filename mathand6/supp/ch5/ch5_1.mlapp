classdef ch5_1 < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        UIFigure       matlab.ui.Figure
        UIAxes         matlab.ui.control.UIAxes
        ButtonGroup    matlab.ui.container.ButtonGroup
        solidButton    matlab.ui.control.RadioButton
        dottedButton   matlab.ui.control.RadioButton
        dashdotButton  matlab.ui.control.RadioButton
        dashedButton   matlab.ui.control.RadioButton
    end


    properties (Access = private)
        Property % Description
        p1
    end


    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
             app.p1=plot(app.UIAxes,sin(0:0.01:2*pi));
        end

        % Selection changed function: ButtonGroup
        function ButtonGroupSelectionChanged(app, event)
            selectedButton = app.ButtonGroup.SelectedObject;
            switch(selectedButton.Text)
                case 'solid'
                app.p1.LineStyle='-';
                case 'dotted'
                app.p1.LineStyle=':';
                case 'dashdot'
                app.p1.LineStyle='-.';
                case 'dashed'
                app.p1.LineStyle='--';
            end
            
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.UIFigure = uifigure;
            app.UIFigure.Name = 'UI Figure';
            app.UIAxes = uiaxes(app.UIFigure);
            title(app.UIAxes, 'Title')
            xlabel(app.UIAxes, 'X')
            ylabel(app.UIAxes, 'Y')
            app.ButtonGroup = uibuttongroup(app.UIFigure);
            app.ButtonGroup.SelectionChangedFcn = createCallbackFcn(app, @ButtonGroupSelectionChanged, true);
            app.ButtonGroup.Title = 'Button Group';
            app.solidButton = uiradiobutton(app.ButtonGroup);
            app.solidButton.Text = 'solid';
            app.solidButton.Value = true;
            app.dottedButton = uiradiobutton(app.ButtonGroup);
            app.dottedButton.Text = 'dotted';
            app.dashdotButton = uiradiobutton(app.ButtonGroup);
            app.dashdotButton.Text = 'dashdot';
            app.dashedButton = uiradiobutton(app.ButtonGroup);
            app.dashedButton.Text = 'dashed';
        end
    end

    methods (Access = public)

        % Construct app
        function app = ch5_1

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.UIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.UIFigure)
        end
    end
end